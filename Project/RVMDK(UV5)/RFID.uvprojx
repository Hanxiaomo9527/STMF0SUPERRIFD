# Keil uVision project RFID.uvprojx, settings and files
target STMF0SUPERRIFD (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: RFID +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F0XX_LD,
  c include: ..\..\Libraries\inc;..\..\Libraries\src;..\..\Libraries\CMSIS\startup;..\..\User;..\..\User\DMA;..\..\User\M500;..\..\User\ToolsFun;..\..\User\USART;..\..\Libraries\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f0xx.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm0plus.h stm32f0xx.h stm32f0xx_conf.h system_stm32f0xx.h core_cm0.h core_cmFunc.h core_cmInstr.h
  group FWLB
    ../../Libraries/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group USER
    ../../User/: main.c stm32f0xx_conf.h system_stm32f0xx.c stm32f0xx_it.c stm32f0xx_it.h
    ../../User/DMA/: DMA.c DMA.h
    ../../User/M500/: M500.c M500.h
    ../../User/ToolsFun/: ToolsFun.c ToolsFun.h
    ../../User/USART/: USART1.c USART1.h
